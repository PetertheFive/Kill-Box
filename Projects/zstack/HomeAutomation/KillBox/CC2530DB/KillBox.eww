<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\KillBox.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>KillBox</project>
        <configuration>CoordinatorEB</configuration>
      </member>
      <member>
        <project>KillBox</project>
        <configuration>RouterEB</configuration>
      </member>
      <member>
        <project>KillBox</project>
        <configuration>EndDeviceEB</configuration>
      </member>
      <member>
        <project>KillBox</project>
        <configuration>RouterZLight</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


